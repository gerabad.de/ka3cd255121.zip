Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_5/temp/tmp_2208_89_GbVUB/format_0/1440(architecture=300).ifc
Time: 2025-08-08T11:36:03
Made in: PARTsolutions

# IfcProject, 1440(architecture=300)
Description: PURO NEXT DUO

# IfcDiscreteAccessory, 1440(architecture=300)
In: BUILDING
Description: 1440(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 1440
ePset_PARTsolutions - NB: 1440(architecture=300); NN: 1440; NT: PURO NEXT DUO; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 1440(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 1440; B: 1440.png; C: PURO NEXT DUO; E: KALDEWEI; EF000049: 1900; EF004567: 900
